/*
 * Device Tree overlay for ALPS rotary input 
 *
 * compile:
 * dtc -@ -I dts -O dtb -o gpio-rotary.dtbo gpio-rotary.dts
 *
 * armbian-add-overlay gpio-rotary.dts
 You only need the to add the compiled <file>.dtbo file to /boot/overlay-user and then enable it in /boot/armbianEnv.txt by adding it to the user_overlays=<file> line.
 */

/dts-v1/;
/plugin/;

/ {
	model = "Orange Pi 5";
	compatible = "rockchip,rk3588s-orangepi-5", "rockchip,rk3588";
  rotary@0 {
			compatible = "rotary-encoder";
			gpios = <&gpio4 RK_PB5 0 GPIO_ACTIVE_LOW>, <&gpio4 RK_PB5 0 GPIO_ACTIVE_LOW>; /* GPIO19 is inverted */
			linux,axis = <0>; /* REL_X */
			rotary-encoder,encoding = "gray";
			rotary-encoder,relative-axis;
		};
/*
		rotary@1 {
			compatible = "rotary-encoder";
			gpios = <&gpio4 RK_PB5 0 GPIO_ACTIVE_LOW>, <&gpio4 RK_PB5 0 GPIO_ACTIVE_LOW>;
			linux,axis = <1>; /* ABS_Y */
			rotary-encoder,steps = <24>;
			rotary-encoder,encoding = "binary";
			rotary-encoder,rollover;
      };
  */
};
